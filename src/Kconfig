## src/Kconfig
```kconfig
config SAINTLY_CUSTOM
	tristate "Saintly pseudo wireless audio driver"
	depends on GENERIC_GPIO
	select SAINTLY
```
